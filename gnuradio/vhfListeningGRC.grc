options:
  parameters:
    generate_options: qt_gui
    id: options_0
    output_language: python
    run_options: run
    title: VHF Listening Station
  states: {}

blocks:
- name: agc_gain
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: agc_rate
  id: variable
  parameters:
    value: '1e-5'
  states: {}
- name: agc_reference
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: audio_decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate / gcd_value)
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,10
    label: Center Frequency
    start: 138e6
    step: 25e3
    stop: 174e6
    value: 162.400e6
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 162.400e6
  states: {}
- name: gcd_value
  id: variable
  parameters:
    value: math.gcd(int(samp_rate), int(quad_rate))
  states: {}
- name: highpass_cutoff_freq
  id: variable
  parameters:
    value: '300'
  states: {}
- name: highpass_trans_width
  id: variable
  parameters:
    value: '50'
  states: {}
- name: interp
  id: variable
  parameters:
    value: int(quad_rate / gcd_value)
  states: {}
- name: lowpass_cutoff_freq
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: lowpass_trans_width
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: audio_rate*audio_decim
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,10
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '48'
  states: {state: disabled}
- name: rfGain
  id: variable
  parameters:
    value: '49'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: agc_rate
    decay_rate: agc_rate
    gain: agc_gain
    max_gain: '65536'
    reference: agc_reference
    type: float
  states: {state: bypassed}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '0.8'
    lo: '-.8'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import os
      import logging
      import sys

      # Add venv to path if needed
      venv_paths = ['/home/pi/vhf-listening/venv/lib/python3.11/site-packages',
                    '/home/carolyn/projects/vhf-listening/venv/lib/python3.11/site-packages',
                    '/home/carolyn/projects/vhf-listening/venv/lib/python3.12/site-packages']
      for venv_path in venv_paths:
          if os.path.exists(venv_path) and venv_path not in sys.path:
              sys.path.insert(0, venv_path)

      try:
          import shout
          from dotenv import load_dotenv
          import lameenc
          SHOUT_AVAILABLE = True
          LAMEENC_AVAILABLE = True
      except ImportError as e:
          print(f'Import error: {e}')
          SHOUT_AVAILABLE = False
          LAMEENC_AVAILABLE = False
          def load_dotenv(x): pass

      logging.basicConfig(level=logging.INFO)
      logger = logging.getLogger(__name__)

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name="Icecast Sink", in_sig=[np.float32], out_sig=None)
              self._load_config()
              self.shout = None
              self.connected = False
              self.encoder = None
              self._setup_encoder()
              logger.info("Icecast sink initialized")
              logger.info(f"Target: {self.icecast_host}:{self.icecast_port}{self.icecast_mount}")

          def _load_config(self):
              try:
                  env_path = os.path.join(os.path.dirname(__file__), '..', '.env')
                  load_dotenv(env_path)
                  self.icecast_host = os.getenv('ICECAST_HOST', 'localhost')
                  self.icecast_port = int(os.getenv('ICECAST_PORT', '8000'))
                  self.icecast_password = os.getenv('ICECAST_PASSWORD', 'hackme')
                  self.icecast_mount = os.getenv('ICECAST_MOUNT', '/stream.mp3')
                  self.stream_name = os.getenv('ICECAST_NAME', 'VHF Listening Station')
                  self.stream_genre = os.getenv('ICECAST_GENRE', 'Radio')
                  logger.info("Icecast configuration loaded")
              except Exception as e:
                  logger.error(f"Config failed: {e}")
                  self.icecast_host = 'localhost'
                  self.icecast_port = 8000
                  self.icecast_password = 'hackme'
                  self.icecast_mount = '/stream.mp3'
                  self.stream_name = 'VHF Listening Station'
                  self.stream_genre = 'Radio'

          def _setup_encoder(self):
              if not LAMEENC_AVAILABLE:
                  logger.error("lameenc not available")
                  return
              try:
                  self.encoder = lameenc.Encoder()
                  self.encoder.set_bit_rate(128)
                  self.encoder.set_in_sample_rate(48000)
                  self.encoder.set_channels(1)
                  self.encoder.set_quality(2)
                  logger.info("MP3 encoder initialized")
              except Exception as e:
                  logger.error(f"Encoder setup failed: {e}")
                  self.encoder = None

          def start(self):
              logger.info("Starting Icecast sink...")
              if not SHOUT_AVAILABLE:
                  logger.error("python-shout not available")
                  return False
              try:
                  self.shout = shout.Shout()
                  self.shout.host = self.icecast_host
                  self.shout.port = self.icecast_port
                  self.shout.user = 'source'
                  self.shout.password = self.icecast_password
                  self.shout.mount = self.icecast_mount
                  self.shout.format = 'mp3'
                  self.shout.protocol = 'http'
                  self.shout.name = self.stream_name
                  self.shout.genre = self.stream_genre
                  self.shout.open()
                  logger.info("Connected to Icecast!")
                  self.connected = True
              except Exception as e:
                  logger.error(f"Connection failed: {e}")
                  self.connected = False
              return True

          def stop(self):
              if self.shout and self.connected:
                  try:
                      self.shout.close()
                  except:
                      pass
              self.connected = False
              return True

          def work(self, input_items, output_items):
              if not self.connected or not self.encoder:
                  return len(input_items[0])
              audio_samples = input_items[0]
              try:
                  pcm_data = (audio_samples * 32767).astype(np.int16)
                  mp3_data = self.encoder.encode(pcm_data)
                  if mp3_data:
                      self.shout.send(bytes(mp3_data))
                      self.shout.sync()
              except Exception as e:
                  logger.error(f"Streaming error: {e}")
                  self.connected = False
              return len(audio_samples)
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: highpass_cutoff_freq
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: highpass_trans_width
    win: window.WIN_KAISER
  states: {state: bypassed}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os; os.environ['QT_QPA_PLATFORM'] = 'offscreen'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: lowpass_cutoff_freq
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: lowpass_trans_width
    win: window.WIN_KAISER
  states: {state: bypassed}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: interp
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: rfGain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', high_pass_filter_0, '0']
- [analog_nbfm_rx_0, '0', analog_agc2_xx_0, '0']
- [analog_rail_ff_0, '0', epy_block_0, '0']
- [high_pass_filter_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_rail_ff_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
