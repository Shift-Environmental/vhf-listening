options:
  parameters:
    generate_options: no_gui
    id: options_0
    output_language: python
    run_options: run
    title: VHF Listening Station
  states: {}

blocks:
- name: agc_gain
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: agc_rate
  id: variable
  parameters:
    value: '1e-5'
  states: {}
- name: agc_reference
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: audio_decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate / gcd_value)
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,10
    label: Center Frequency
    start: 138e6
    step: 25e3
    stop: 174e6
    value: 162.400e6
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 162.400e6
  states: {}
- name: gcd_value
  id: variable
  parameters:
    value: math.gcd(int(samp_rate), int(quad_rate))
  states: {}
- name: highpass_cutoff_freq
  id: variable
  parameters:
    value: '300'
  states: {}
- name: highpass_trans_width
  id: variable
  parameters:
    value: '50'
  states: {}
- name: interp
  id: variable
  parameters:
    value: int(quad_rate / gcd_value)
  states: {}
- name: lowpass_cutoff_freq
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: lowpass_trans_width
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: audio_rate*audio_decim
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,10
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '48'
  states: {state: disabled}
- name: rfGain
  id: variable
  parameters:
    value: '48'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: agc_rate
    decay_rate: agc_rate
    gain: agc_gain
    max_gain: '65536'
    reference: agc_reference
    type: float
  states: {state: bypassed}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '0.8'
    lo: '-.8'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/vhf_audio_pipe
    type: float
    unbuffered: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: highpass_cutoff_freq
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: highpass_trans_width
    win: window.WIN_KAISER
  states: {state: bypassed}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: lowpass_cutoff_freq
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: lowpass_trans_width
    win: window.WIN_KAISER
  states: {state: bypassed}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: interp
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    center_freq: freq
    gain: rfGain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', high_pass_filter_0, '0']
- [analog_nbfm_rx_0, '0', analog_agc2_xx_0, '0']
- [analog_rail_ff_0, '0', blocks_file_sink_0, '0']
- [high_pass_filter_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_rail_ff_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
